* C:\Users\Dell\eSim-Workspace\resistors\resistors.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/08/22 23:08:48

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
scmode1  SKY130mode
v1  VDD GND DC
SC1  Net-_SC1-Pad1_ VDD VDD sky130_fd_pr__res_generic_pd
SC2  Net-_SC2-Pad1_ Net-_SC1-Pad1_ VDD sky130_fd_pr__res_generic_pd
X1  VDD VSS VDD VIN Net-_U8-Pad1_ GND avsd_opamp
v2  VSS GND DC
SC3  Net-_SC3-Pad1_ Net-_SC2-Pad1_ VDD sky130_fd_pr__res_generic_pd
X2  VDD VSS Net-_SC1-Pad1_ VIN Net-_U8-Pad2_ GND avsd_opamp
v3  VIN GND DC
X3  VDD VSS Net-_SC2-Pad1_ VIN Net-_U8-Pad3_ GND avsd_opamp
SC4  Net-_SC4-Pad1_ Net-_SC3-Pad1_ VDD sky130_fd_pr__res_generic_pd
SC5  Net-_SC5-Pad1_ Net-_SC4-Pad1_ VDD sky130_fd_pr__res_generic_pd
SC6  Net-_SC6-Pad1_ Net-_SC5-Pad1_ VDD sky130_fd_pr__res_generic_pd
SC7  GND Net-_SC6-Pad1_ VDD sky130_fd_pr__res_generic_pd
X4  VDD VSS Net-_SC3-Pad1_ VIN Net-_U8-Pad4_ GND avsd_opamp
X5  VDD VSS Net-_SC4-Pad1_ VIN Net-_U8-Pad5_ GND avsd_opamp
X6  VDD VSS Net-_SC5-Pad1_ VIN Net-_U8-Pad6_ GND avsd_opamp
X7  VDD VSS Net-_SC6-Pad1_ VIN Net-_U8-Pad7_ GND avsd_opamp
U8  Net-_U8-Pad1_ Net-_U8-Pad2_ Net-_U8-Pad3_ Net-_U8-Pad4_ Net-_U8-Pad5_ Net-_U8-Pad6_ Net-_U8-Pad7_ Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad5_ Net-_U10-Pad6_ Net-_U10-Pad7_ adc_bridge_7
U9  Net-_U10-Pad8_ Net-_U10-Pad9_ Net-_U10-Pad10_ Net-_U10-Pad11_ Net-_U10-Pad12_ Net-_U10-Pad13_ Net-_U10-Pad14_ Net-_SC13-Pad2_ Net-_SC9-Pad2_ Net-_SC8-Pad2_ Net-_SC14-Pad2_ Net-_SC11-Pad2_ Net-_SC10-Pad2_ Net-_SC12-Pad2_ dac_bridge_7
U10  Net-_U10-Pad1_ Net-_U10-Pad2_ Net-_U10-Pad3_ Net-_U10-Pad4_ Net-_U10-Pad5_ Net-_U10-Pad6_ Net-_U10-Pad7_ Net-_U10-Pad8_ Net-_U10-Pad9_ Net-_U10-Pad10_ Net-_U10-Pad11_ Net-_U10-Pad12_ Net-_U10-Pad13_ Net-_U10-Pad14_ preencoder
SC8  Net-_SC15-Pad1_ Net-_SC8-Pad2_ GND GND sky130_fd_pr__nfet_01v8_lvt
SC9  Net-_SC10-Pad1_ Net-_SC9-Pad2_ GND GND sky130_fd_pr__nfet_01v8_lvt
SC10  Net-_SC10-Pad1_ Net-_SC10-Pad2_ GND GND sky130_fd_pr__nfet_01v8_lvt
SC13  Net-_SC11-Pad1_ Net-_SC13-Pad2_ GND GND sky130_fd_pr__nfet_01v8_lvt
SC14  Net-_SC11-Pad1_ Net-_SC14-Pad2_ GND GND sky130_fd_pr__nfet_01v8_lvt
SC11  Net-_SC11-Pad1_ Net-_SC11-Pad2_ GND GND sky130_fd_pr__nfet_01v8_lvt
SC12  Net-_SC11-Pad1_ Net-_SC12-Pad2_ GND GND sky130_fd_pr__nfet_01v8_lvt
U1  out1 plot_v1
U2  out2 plot_v1
U3  out3 plot_v1
SC15  Net-_SC15-Pad1_ VDD VDD sky130_fd_pr__res_generic_pd
SC16  Net-_SC10-Pad1_ VDD VDD sky130_fd_pr__res_generic_pd
SC17  Net-_SC11-Pad1_ VDD VDD sky130_fd_pr__res_generic_pd
U4  Net-_SC15-Pad1_ Net-_SC10-Pad1_ Net-_SC11-Pad1_ Net-_U4-Pad4_ Net-_U4-Pad5_ Net-_U4-Pad6_ adc_bridge_3
U11  Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ out1 out2 out3 dac_bridge_3
U5  Net-_U4-Pad4_ Net-_U4-Pad5_ Net-_U4-Pad6_ Net-_U11-Pad1_ Net-_U11-Pad2_ Net-_U11-Pad3_ postencoder
U6  VIN plot_v1

.end
